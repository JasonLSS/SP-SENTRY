# Keil uVision project SP19_Template_lite.uvprojx, settings and files
target SP19_Template_lite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SP19_Template_lite +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427xx,STM32F427_437xx,USE_STDPERIPH_DRIVER,MPU6500,ARM_MATH_CM4,SP19
  c include: ..\STMLib;..\STMLib\CMSIS\Include;..\STMLib\STM32F4xx_StdPeriph_Driver\inc;..\STMLib\STM32_USB_OTG_Driver\inc;..\STMLib\STM32_USB_HOST_Library\Core\inc;..\STMLib\STM32_USB_Device_Library\Core\inc;..\STMLib\STM32_USB_Device_Library\Class\cdc\inc;..\SPLib;..\SPLib\USB;..\SPLib\BSP;..\SPLib\AAL;..\SPLib\APP;..\SPLib\eMPL;..\SPLib\USB;..\User;..\User\Config;..\SPLib\View2MCU_ComProtocal
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c sp_irq.c sp_task.c
  group APP
    ../SPLib/APP/: sp_utility.c sp_chasis.c sp_motor.c sp_rc.c RefereeInfo.c gimbal.c
  group AAL
    ../SPLib/AAL/: sp_math.c sp_pid.c sp_filter.c
  group BSP
    ../SPLib/ASM/: sp_delay.s
    ../SPLib/BSP/: sp_usart.c sp_gpio.c sp_dma.c sp_can.c
  group MPL
    ../SPLib/BSP/: sp_spi.c
    ../SPLib/eMPL/: sp_imu.c AHRS.lib AHRS_middleware.c kalman.c
  group View
    ../SPLib/View2MCU_ComProtocal/: frame.c Auto_aim.c
  group USB
    ../SPLib/USB/: usb.c usb_bsp.c usbd_usr.c usbd_desc.c usbd_cdc_if.c
    ../SPLib/: SP19_USB.lib
  group CORE
    ../STMLib/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../STMLib/: STM32F427_StdPeriph_Driver.lib
    ../User/: startup_stm32f427II.s system_stm32f427II.c
  group DOC
    ./: config.template
    ../SPLib/: DMA_Channels.md MPU6050_RegDesc.md MPU6500_Desc.md
